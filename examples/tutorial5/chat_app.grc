<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>chat_app</value></param>
<param><key>author</key><value>Martin Braun</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>A chat app that uses message passing</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>MessagePassingChatApp</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>QPSK</value></param>
<param><key>const_points</key><value>[1+1j, -1+1j, 1-1j, -1-1j]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1, 3, 2]</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>msg_str</value></param>
<param><key>value</key><value>Hello World!</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"tsb_tag"</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>2</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>"tsb_tag"</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1</value></param>
<param><key>k</key><value>2</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>"tsb_tag"</value></param>
<param><key>align_output</key><value>True</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"tsb_tag"</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>QPSK.points()</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_0</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>myblocks_qpsk_demod_v2</key>
<param><key>id</key><value>myblocks_qpsk_demod_v2_0</value></param>
<param><key>gray_code</key><value>1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>rx_data</value></param>
<param><key>stream_id</key><value>QPSK Data</value></param>
</block>
<block>
<key>tutorial_chat_receiver</key>
<param><key>id</key><value>tutorial_chat_receiver_0</value></param>
</block>
<block>
<key>tutorial_chat_sanitizer</key>
<param><key>id</key><value>tutorial_chat_sanitizer_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>prefix</key><value>UserName</value></param>
<param><key>msg</key><value>msg_str</value></param>
</block>
<block>
<key>tutorial_my_qpsk_demod_cb</key>
<param><key>id</key><value>tutorial_my_qpsk_demod_cb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gray_code</key><value>True</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>tx_data</value></param>
<param><key>stream_id</key><value>QPSK Data</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>digital_crc32_async_bb_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>tx_data</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_0</source_block_id><sink_block_id>tutorial_chat_receiver_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>myblocks_qpsk_demod_v2_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_data</source_block_id><sink_block_id>myblocks_qpsk_demod_v2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_data</source_block_id><sink_block_id>tutorial_my_qpsk_demod_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tutorial_chat_sanitizer_0</source_block_id><sink_block_id>digital_crc32_async_bb_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tutorial_my_qpsk_demod_cb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
